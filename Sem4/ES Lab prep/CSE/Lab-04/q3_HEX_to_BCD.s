	AREA RESET,DATA,READONLY
	EXPORT __Vectors
__Vectors
	DCD 0X10001000
	DCD Reset_Handler
	ALIGN
	AREA my_code,CODE,READONLY
	ENTRY
	EXPORT Reset_Handler
Reset_Handler
	LDR R0,=VAL1
	LDR R2,=UNPACKED_RES
	LDRH R3,[R0]
QUO RN R5
COUNTER RN R7
	MOV COUNTER ,#0
L1	CMP R3,#10
	BLO L2
	BL DIVISION
L2	STRB R3,[R2],#1
	ADD COUNTER,#1
	MOV R3,QUO
	MOV QUO,#0
	CMP R3,#10
	BHS L1
	STRB R3,[R2]
	ADD COUNTER,#1
	
	LDR R4,=UNPACKED_RES
	LDR R6,=PACKED_RES
L3	BL PACKED
	STRB R11,[R6],#1
	SUB COUNTER,#2
	CMP COUNTER,#1
	BEQ L4
	CMP COUNTER,#0
	BEQ STOP
	B L3
L4	BL PACKED
	STRB R11,[R6]
	B STOP
STOP B STOP
DIVISION
	CMP R3,#10
	BLO DIV_L1
	SUB R3,#10
	ADD QUO,#1
	B DIVISION
DIV_L1 BX LR
PACKED
	LDRB R10,[R4],#1
	LDRB R11,[R4],#1
	LSL R11,#4
	ADD R11,R10
	BX LR
VAL1 DCW 0XAB23
	AREA my_data,DATA,READWRITE
UNPACKED_RES SPACE 64
PACKED_RES DCD 0
	END