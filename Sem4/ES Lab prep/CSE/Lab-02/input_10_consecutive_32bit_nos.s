 	AREA RESET, DATA,READONLY
	EXPORT __Vectors
__Vectors
	DCD 0X10001000
	DCD Reset_Handler
	ALIGN
	AREA mycode,CODE,READONLY
	ENTRY
	EXPORT Reset_Handler
Reset_Handler
	LDR R0,=SRC
	LDR R1,=DST
	MOV R2,#10
	mov r3,#10
	mov r4,#0x1
l2	str r4,[r0],#4
	add r4,#0x1
	subs r3,#1
	bne l2
L1	ROR R0,#4
	SUBS R2,#1
	BNE L1
STOP B STOP

	AREA my_data,DATA,READWRITE
SRC DCD 0X1,0X2,0X3,0X4,0X5,0X6,0X7,0X8,0X9,0XA
DST DCD 0 
	END