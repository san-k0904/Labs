 	AREA RESET, DATA,READONLY
	EXPORT __Vectors
__Vectors
	DCD 0X10001000
	DCD Reset_Handler
	ALIGN
	AREA mycode,CODE,READONLY
	ENTRY
	EXPORT Reset_Handler
Reset_Handler
	LDR R0,=SRC
	LDR R1,[R0]
	MOV R2,#0
	MOV R3,#1
	LDR R0,=DST
	CMP R1,#1
	BLO STOP
	STRB R2,[R0],#1
	SUBS R1,#1
	BEQ STOP
	STRB R3,[R0],#1
	SUBS R1,#1
	BEQ STOP
L2	BL FIBONNACI
	STRB R3,[R0],#1
	SUBS R1,#1
	BNE L2
STOP B STOP
FIBONNACI
	ADD R4,R2,R3
	MOV R2,R3
	MOV R3,R4
	BX LR
SRC DCD 0X5
	AREA my_data,DATA,READWRITE
DST DCD 0
	END