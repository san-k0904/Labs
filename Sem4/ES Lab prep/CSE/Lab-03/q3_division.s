 	AREA RESET, DATA,READONLY
	EXPORT __Vectors
__Vectors
	DCD 0X10001000
	DCD Reset_Handler
	ALIGN
	AREA mycode,CODE,READONLY
	ENTRY
	EXPORT Reset_Handler
Reset_Handler
	LDR R0,=VAL1
	LDR R1,=VAL2
	LDR R5,=QUO
	LDR R6,=REM
	LDR R2,[R0]
	LDR R3,[R1]
	MOV R4,#0
	BL DIVISION
	STR R2,[R6]
	STR R4,[R5]
STOP B STOP
VAL1 DCD 0X14
VAL2 DCD 0X4
DIVISION
L1	CMP R2,R3
	BCC L2
	SUB R2,R3
	ADD R4,#1
	B L1
L2	BX LR
	AREA my_data,DATA,READWRITE
QUO DCD 0
REM DCD 0
	END
