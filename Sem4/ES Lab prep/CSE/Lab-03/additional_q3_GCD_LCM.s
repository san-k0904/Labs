 	AREA RESET, DATA,READONLY
	EXPORT __Vectors
__Vectors
	DCD 0X10001000
	DCD Reset_Handler
	ALIGN
	AREA mycode,CODE,READONLY
	ENTRY
	EXPORT Reset_Handler
Reset_Handler
	LDR R0,=VAL1
	LDR R1,=VAL2
	LDR R2,[R0]
	LDR R3,[R1]
	MOV R7,R2
	MOV R8,R3
REM RN R4
	LDR R5,=GCD
	LDR R6,=LCM
	BL GCDFN
	STR R7,[R5]
	MOV R10,#0;
QUO RN R10
	BL LCM_FN
	STR R9,[R6]
	
STOP B STOP

GCDFN
L3	CMP R7,R8
	BEQ L1
	MOV REM,R7
DIV_GCD	CMP REM,R8
	BLS L2
	SUBS REM,R8
	B DIV_GCD
L2	MOV R7,R8
	MOV R8,REM
	B L3
L1	BX LR


LCM_FN
	MUL R9,R2,R3;
DIV_LCM CMP R9,R7
	BCC L4
	SUBS R9,R7
	ADD QUO,#1
	B DIV_LCM
L4	BX LR


VAL1 DCD 0XC
VAL2 DCD 0X6
	AREA my_data,DATA,READWRITE
GCD DCD 0
LCM DCD 0
	END
	