 	AREA RESET, DATA,READONLY
	EXPORT __Vectors
__Vectors
	DCD 0X10001000
	DCD Reset_Handler
	ALIGN
	AREA mycode,CODE,READONLY
	ENTRY
	EXPORT Reset_Handler
Reset_Handler
	LDR R0,=VAL1
	LDR R1,=VAL2
	LDR R2,=RESULT
	BL SUBTRACTION	
	STR R7,[R2]
STOP B STOP
SUBTRACTION	
	LDR R7,[R0]
	LDR R8,[R1]
	SUBS R7,R8
	BX LR
VAL1 DCD 0X8
VAL2 DCD 0X4
	AREA my_data, DATA,READWRITE
RESULT DCD 0
	END
	

	