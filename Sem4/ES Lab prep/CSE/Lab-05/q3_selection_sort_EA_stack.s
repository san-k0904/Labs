	AREA RESET,DATA,READONLY
	EXPORT __Vectors
__Vectors
	DCD 0X10001000
	DCD Reset_Handler
	ALIGN
	AREA mycode,CODE,READONLY
	EXPORT Reset_Handler
Reset_Handler
	LDR R0,=0X5
	LDR R1,=0X4
	LDR R2,=0X7
	LDR R3,=0X2
	LDR R4,=0X1
	LDR R5,=0X6
	LDR R6,=0X9
	LDR R7,=0XA
	LDR R8,=0X3
	LDR R9,=0X8
	STM R13!,{R0-R9}
	
	MOV R2,R13; ITH INDEX;TOS
MAX RN R12
I_COUNTER RN R0
J_COUNTER RN R1
	MOV I_COUNTER,#0; I COUNTER FOR I LOOP
	MOV J_COUNTER,#0; J COUNTER FOR J LOOP
L1	MOV R3,R2
	MOV MAX,R2 ; MAX INDEX=ITH INDEX
	ADD J_COUNTER,I_COUNTER,#1; J=I+1
L2	SUB R3,#4 ; JTH INDEX
	
	LDMDB MAX,{R7}; A[MAX]
	LDMDB R3,{R8};A[J]
	CMP R8,R7 ; COMPARE A[J] A[MAX]
	BLO BRANCH
	MOV MAX,R3
BRANCH	ADD J_COUNTER,#1; J=J+1
	CMP J_COUNTER,#10
	BNE L2
	LDMDB R2!,{R4}
	LDMDB MAX!,{R5}
	STM R2,{R5}
	STM MAX,{R4}
	ADD I_COUNTER,#1
	CMP I_COUNTER,#9
	BNE L1
STOP B STOP
	END
	
	

	