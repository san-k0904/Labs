	AREA RESET,DATA,READONLY
	EXPORT __Vectors
__Vectors
	DCD 0X10001000
	DCD Reset_Handler
	ALIGN
	AREA mycode,CODE,READONLY
	EXPORT Reset_Handler
Reset_Handler
	LDR R0,=SRC
	LDR R12,=DST
	BL COPY
	LDR R0,=DST
	
MIN RN R1;
	MOV R2,#0; I
	MOV R3,#0;J
	MOV MIN,R2;MININIMUM VALUE INDEX
I_COUNTER RN R4
J_COUNTER RN R5
	MOV I_COUNTER,#16
	MOV J_COUNTER,#20
L1	MOV MIN,R2;
	ADD R3,R2,#4;J=I+1
	;COZ 32 BIT NUMBER EACH IN ARRAY SO J+=1 SHOULD INCREASE BY 4 BYTES
L2	LDR R8,[R0,MIN];A[MIN]
	LDR R9,[R0,R3];A[J]
	CMP R9,R8
	BHS BRANCH
	MOV MIN,R3
BRANCH	ADD R3,#4
	CMP R3,J_COUNTER
	BNE L2
	LDR R6,[R0,R2];A[I]
	LDR R8,[R0,MIN];A[MIN]
	STR R8,[R0,R2];STORE A[MIN] AT A[I]
	STR R6,[R0,MIN]
	ADD R2,#4
	CMP R2,I_COUNTER
	BNE L1
STOP B STOP

COPY
	MOV R10,#5
C1	LDR R11,[R0],#4
	STR R11,[R12],#4
	SUBS R10,#1
	BNE C1
	BX LR
SRC DCD 0X3,0X4,0X1,0X5,0X2
	AREA mydata,DATA,READWRITE
DST DCD 0
	END
	
	
	
	
	