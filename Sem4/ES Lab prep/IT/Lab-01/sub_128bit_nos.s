 	AREA RESET, DATA,READONLY
	EXPORT __Vectors
__Vectors
	DCD 0X10001000
	DCD Reset_Handler
	ALIGN
	AREA mycode,CODE,READONLY
	ENTRY
	EXPORT Reset_Handler
Reset_Handler
	LDR R0,=VAL1
	LDR R1,=VAL2
	LDR R2,=RESULT
	MOV R3,#3
	MOV R4,#4
	MLA R0,R3,R4,R0
	MLA R1,R3,R4,R1
	BL SUBTRACTION	
	STR R7,[R2],#4
	STR R9,[R2],#4
	BL SUBTRACTION	
	STR R7,[R2],#4
	STR R9,[R2],#4
STOP B STOP
SUBTRACTION	
	LDR R7,[R0],#-4
	LDR R8,[R1],#-4
	LDR R9,[R0],#-4
	LDR R10,[R1],#-4
	SUBS R7,R8
	SBC R9,R10
	BX LR
VAL1 DCD 0X5,0X6,0X7,0X3
VAL2 DCD 0X1,0X2,0X3,0X4
	AREA my_data, DATA,READWRITE
RESULT DCD 0
	END
	

	